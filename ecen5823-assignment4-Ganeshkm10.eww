<?xml version="1.0" encoding="iso-8859-1"?>
<!-- This file was generated by Simplicity Studio -->
<workspace>
  <project>
    <path>$WS_DIR$\ecen5823-assignment4-Ganeshkm10.ewp</path>
  </project>
  <batchBuild/>
</workspace>
